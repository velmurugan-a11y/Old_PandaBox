# Keil uVision project cdc_acm.uvprojx, settings and files
target cdc_acm (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F305RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.0
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cdc_acm +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_CL,USE_USB_FS
  c misc: --c99
  c include: ..\inc;..\..\..\..\..\..\GD32F30x_Firmware_Library\CMSIS\GD\GD32F30x\Include;..\..\..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_standard_peripheral\Include;..\..\..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_usbfs_library\driver\Include;..\..\..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_usbfs_library\device\core\Include;..\..\..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_usbfs_library\device\class\cdc\Include;..\..\..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_usbfs_library\ustd\common;..\..\..\..\..\..\GD32F30x_Firmware_Library\GD32F30x_usbfs_library\ustd\class\cdc;..\..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../src/: app.c gd32f30x_it.c gd32f30x_hw.c
  group CMSIS
    ../src/: system_gd32f30x.c
  group GD32F30x_StdPeriph_Driver
    ../../../../../../GD32F30x_Firmware_Library/GD32F30x_standard_peripheral/Source/: gd32f30x_ctc.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_rcu.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_pmu.c
  group GD32F30x_START
    ../../../../../Utilities/: gd32f305r_start.c
  group USB_Drivers
    ../../../../../../GD32F30x_Firmware_Library/GD32F30x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../../../../../GD32F30x_Firmware_Library/GD32F30x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../../../../../GD32F30x_Firmware_Library/GD32F30x_usbfs_library/device/class/cdc/Source/: cdc_acm_core.c
  group Startup
    ../../../../../../GD32F30x_Firmware_Library/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_cl.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.3.0
